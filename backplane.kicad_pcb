# Repository dron23/ic880a-backplane

File README.md:

# iC880A + Raspberry Pi Backplane

This is a fork of original iC880A + Raspberry Pi Backplane by [coredump.ch](https://github.com/dbrgn/ic880a-backplane).

This is a backplane to connect an iC880A-SPI concentrator board to a Raspberry
Pi. It is inspired by the [iC880A backplane by
@gonzalocasas](https://github.com/gonzalocasas/ic880a-backplane), but aims to
give you the following additional features:

Power

- Screw terminal and footprint for MP1584 step-down regulator module (6.7-28V)
- Alternative step-down regulator is LM2596 Module
- Screw terminal for direct power input/output (5V)
- Protection diode and resettable polyfuse against high voltage spikes
- Protection against reverse polarity power input

Headers

- Full access to Raspberry Pi GPIO header
- Pin header for serial communication (RX/TX)
- 2 Pin headers for I²C based sensors (SDA/SCL/GND/3.3V/5V)

Sensors

- A [SHT21](https://sensirion.com/sht21/) temperature/humidity sensor
- A header for alternative temperature/humidity sensor DHT22
- An MCP3425 16-bit ADC to measure RPi supply voltage

Other

- Pin header with flyback diode for 5V fan (5V/GND)
- A hole for mounting of the fan
- General purpose button connected to GPIO pin (e.g. for controlled Raspi
  shutdown)
- Three general purpose SMD LEDs (Note: Only usable from Raspi versions
  with 40-pin GPIO header)
- Mounting holes for Raspberry Pi B+ / 2B / 3B / Zero
- Compatibility with PoE hat
- UART link from GPS module on ic880a to Raspberry Pi

## PCB

## Schematics

See [ic880a_rp1_backplane_v1.2-2.pdf](ic880a_rp1_backplane_v1.2-2.pdf).

## Development

This PCB was created using KiCad 5.1 (5.1.4-3.fc30).

## License

- © 2017–2018 Danilo Bargen. Licensed under the TAPR Open Hardware License (www.tapr.org/OHL).
- © 2019 Jiri Slezka, CIT / SU, jiri.slezka@slu.cz

## KiCad design backplane.kicad_pcb

Parts:
C1, C3: 100nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: LED_Blue; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D2: LED_Yellow; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D3: LED_Red; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D4, D6: SS14; D_2114_3652Metric
D5: TVSD SMBJ5.0A; D_2114_3652Metric; Digikey SMBJ5.0A-E3/5BGICT-ND
F1: PolySwitch (PTC); C_1812_4532Metric_Pad1.30x3.40mm_HandSolder; Digikey MF-MSMF250/16X-2CT-ND
J1, J2: I2C; header_1x5_unmarked
J3: SER; header_1x2_unmarked
J4, J5: PWR; TerminalBlock_Phoenix_MPT-0,5-2-2.54_1x02_P2.54mm_Horizontal
J6: FAN; header_1x2_unmarked
J7: PPS; header_1x1_unmarked
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
Q4: Q_NMOS_GSD; SOT-23
Q5: Q_PMOS_GSD; SOT-23
R1: 82Ω 1/8W; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R2: 330Ω 1/8W; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R3: 220Ω 1/8W; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4, R5, R9, R13: 10kΩ; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R6: 4.7kΩ; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R10: 6.8kΩ; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R11: 3.6kΩ; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12: 470Ω; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; SW_Mikroshop
U1: Raspberry_Pi_2_3; PinHeader_2x20_P2.54mm_Vertical
U2: IC880A-SPI
U3: DHT22; PinHeader_1x04_P2.54mm_Vertical
U4: MP1584_MODULE; MP1584_MODULE_ZVEPOWER
U5: MCP3425A0T-E/CH; SOT-23-6_Handsoldering
U6: SHTC3; SHTC1
U7: LM2596_MODULE

Connections:
3.3V: C1.2, J1.4 (3.3V), J2.4 (3.3V), R4.1, R5.1, R6.2, U1.1 (3V3), U1.17 (3V3), U3.1 (VCC), U5.5 (VDD), U6.1 (VDD)
5V: D4.1 (K), D5.1 (K), J1.5 (5V), J2.5 (5V), J6.2 (5V), Q5.2 (S), R10.1, U1.2 (5V), U1.4 (5V), U2.21 (VDD)
BTN: SW1.1, U1.32 (GPIO12)
CE0: U1.24 ((~SPI_CE0~)_GPIO8), U2.17 (NSS)
CLK: U1.23 ((SPI_SCLK)_GPIO11), U2.14 (CLK)
DHT_IO: R6.1, U1.15 (GPIO22_(GEN3)), U3.2 (IO)
FAN: Q4.1 (G), R9.2, U1.12 (GPIO18_(GEN1))
GND: C1.1, D1.1 (K), D2.1 (K), D3.1 (K), D5.2 (A), J1.3 (GND), J2.3 (GND), J4.1 (GND), Q4.2 (S), R9.1, R12.2, R13.1, SW1.2, U1.9 (GND), U1.14 (GND), U1.20 (GND), U1.25 (GND), U1.30 (GND), U1.34 (GND), U1.39 (GND), U2.1 (GND), U2.12 (GND), U2.20 (GND), U2.22 (GND), U2.24 (GND), U3.4 (GND), U4.4 (OUT-), U5.2 (VSS), U6.4 (VSS), U7.3 (OUT-)
GPS_RST: U1.29 (GPIO5), U2.3 (nGPS_Reset)
GPS_SUP: U1.31 (GPIO6), U2.5 (EN_GPS_Supply)
IC880A_RST: U1.22 (GPIO25_(GEN6)), U2.13 (Reset)
LED1: R1.1, U1.40 (GPIO21)
LED2: R2.1, U1.38 (GPIO20)
LED3: R3.1, U1.36 (GPIO16)
MISO: U1.21 ((SPI_MISO)_GPIO9), U2.15 (MISO)
MOSI: U1.19 ((SPI_MOSI)_GPIO10), U2.16 (MOSI)
unnamed: C3.1, R11.2, R12.1, U5.6 (Vin-)
unnamed: C3.2, R10.2, R11.1, U5.1 (Vin+)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), J6.1 (GND), Q4.3 (D)
unnamed: D6.1 (K), J5.2 (VCC), U4.2 (IN+), U4.5 (EN), U7.1 (IN+)
unnamed: D6.2 (A), F1.1, J4.2 (VCC), U4.3 (OUT+), U7.4 (OUT+)
unnamed: F1.2, Q5.3 (D)
unnamed: J5.1 (GND), U4.1 (IN-), U7.2 (IN-)
unnamed: JP1.1 (A), U2.26 (GPS_RX)
unnamed: JP2.1 (A), U2.25 (GPS_TX)
unnamed: Q5.1 (G), R13.2
PPS: J7.1, U2.19 (PPS)
RX: J3.2 (RX), JP2.2 (B), U1.10 ((RXD0)_GPIO15)
SCL: J1.2 (SCL), J2.2 (SCL), R5.2, U1.5 ((SCL1)_GPIO3), U5.3 (SCL), U6.2 (SCL)
SDA: J1.1 (SDA), J2.1 (SDA), R4.2, U1.3 ((SDA1)_GPIO2), U5.4 (SDA), U6.3 (SDA)
TX: J3.1 (TX), JP1.2 (B), U1.8 ((TXD0)_GPIO14)

Notes on the sheet:
Raspberry Pi
iC880A
LEDs
SHTC3 Sensor
I²C Breakouts
Power
ADC
DC Fan
Connector for a 5V DC fan with a flyback diode.
This is a 16-Bit Analog-to-Digital Converter that is wired up to measure the Raspberry Pi supply voltage.
The board includes a 5V power input/output connector as well as a MP1584 or LM2596 step-down voltage regulator for 6.7-28V input.
The Sensirion SHTC3 sensor measures both temperature and humidity.
Button
A simple button connected to GPIO12. It could be programmed to shut down the Rpi on button press. Note that you need to enable the internal pull-up for the button to work.
Additionally, the parts are protected against voltage spikes by a resettable fuse and a TVS diode, and against reverse polarity by a MOSFET.
Accuracy SHTC3: ±0.2°C / ±2%RH
I²C Pull-Ups
DHT22

Board: 2 copper layers, 93.9 x 88.4 mm, 39 parts (3 on the bottom side), 34 nets.

## Commit log

2019-08-12 modifikace pro FEI/VSB
2019-08-15 fan hole, space tunning
2019-08-16 minor tunning
2019-08-22 Added texts, ground vias and minor tuning. This version 2.1-1 ready for prototyping
2019-08-24 values in schematics moved into value field, generated BOM
2019-08-27 BOM changes
2019-10-14 verze 2.1-2
2019-10-14 cleaning
2019-10-16 added serial link to gps module on ic880a
